# IAR project Project.ewp, settings and files
configuration STM32F207 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207VC ST STM32F207VC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_USB_OTG_FS
  ICCARM.CCIncludePath2: ..; ..\..\..\01-Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\01-Libraries\CMSIS\Include; ..\USBAPP; ..\..\..\01-Libraries\STM32_USB_Device_Library\Class\msc\inc; ..\..\..\01-Libraries\STM32_USB_Device_Library\Core\inc; ..\..\..\01-Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\01-Libraries\CMSIS\Device\ST\STM32F2xx\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../01-Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group EWARM
    ../../../01-Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/iar/: startup_stm32f2xx.s
  group STM32F2xx_StdPeriph_Driver
    ../../../01-Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group STM32F2xx_USB_Library/Device_Library/Core
    ../../../01-Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group STM32F2xx_USB_Library/Device_Library/MSC
    ../../../01-Libraries/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group STM32F2xx_USB_Library/USB_OTG_Driver
    ../../../01-Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group User
    ../: Ex_Flash.c LCD_disp.c main.c stm32f2x_sdio_sd.c stm32f2xx_it.c
  group User/USBAPP
    ../USBAPP/: usb_bsp.c usb_conf.h usbd_conf.h usbd_desc.c usbd_desc.h usbd_storage_msd.c usbd_usr.c
