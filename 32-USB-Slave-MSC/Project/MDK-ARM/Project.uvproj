# Keil uVision project Project.uvproj, settings and files
target STM32F207VC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM32F207VC
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_USB_OTG_FS
  c include: ..\..\..\01-Libraries\CMSIS\Include;..\..\..\01-Libraries\CMSIS\Device\ST\STM32F2xx\Include;..\..\..\01-Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\01-Libraries\STM32_USB_OTG_Driver\inc;..\..\..\01-Libraries\STM32_USB_Device_Library\Core\inc;..\..\..\01-Libraries\STM32_USB_Device_Library\Class\msc\inc;..\USBAPP;..\..\Project
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../../../01-Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group STM32F2xx_StdPeriph_Driver
    ../../../01-Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group USB_DEVICE_CORE
    ../../../01-Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USB_DEVICE_MSC
    ../../../01-Libraries/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USB_OTG
    ../../../01-Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group MDK-ARM
    ../../../01-Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f2xx.s
  group USBAPP
    ../USBAPP/: usb_bsp.c usb_conf.h usbd_conf.h usbd_desc.c usbd_desc.h usbd_storage_msd.c usbd_usr.c
  group User
    ../: main.c stm32f2xx_it.c Ex_Flash.c LCD_disp.c stm32f2x_sdio_sd.c
