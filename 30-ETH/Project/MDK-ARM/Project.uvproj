# Keil uVision project Project.uvproj, settings and files
target STM32_ETH (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM322xG_EVAL
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM322xG_EVAL
  c include: ..\inc;..\inc\app;..\inc\lwip;..\..\Libraries\STM32F2x7_ETH_Driver\inc;..\..\Third_Party\lwip-1.4.1;..\..\Third_Party\lwip-1.4.1\src\include;..\..\Third_Party\lwip-1.4.1\src\include\ipv4;..\..\..\01-Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\01-Libraries\STM32F2x7_ETH_Driver\inc;..\..\..\01-Libraries\CMSIS\Include;..\..\..\01-Libraries\CMSIS\Device\ST\STM32F2xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../../../01-Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group api
    ../../Third_Party/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group core
    ../../Third_Party/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group ipv4
    ../../Third_Party/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group netif
    ../src/lwip/: ethernetif.c
    ../../Third_Party/lwip-1.4.1/src/netif/: etharp.c
  group STM32F2xx_StdPeriph_Driver
    ../../../01-Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
    ../../../01-Libraries/STM32F2x7_ETH_Driver/src/: stm32f2x7_eth.c
  group MDK-ARM
    ../../../01-Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f2xx.s
  group User
    ../src/app/: hard_bsp.c main.c LCD_disp.c
    ../src/: stm32f2xx_it.c
    ../src/lwip/: lwip_app.c stm32f2x7_eth_bsp.c
